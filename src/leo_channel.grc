options:
  parameters:
    author: Yi-Kuang Evan Chen
    generate_options: qt_gui
    id: leo_channel
    output_language: python
    title: LEO Satellite Channel Emulator
  states: {}

blocks:
- name: dl_band_fc
  id: variable
  parameters:
    value: '2680000000'
  states: {}
- name: doppler_freq
  id: variable_qtgui_range
  parameters:
    rangeType: int
    start: '0'
    step: '100'
    stop: '100000'
    value: '0'
  states: {}
- name: nodeb_addr
  id: variable
  parameters:
    value: '"tcp://10.141.51.18:2000"'
  states: {}
- name: prop_delay
  id: variable
  parameters:
    value: '50'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '23040000'
  states: {}
- name: sat_altitude
  id: variable
  parameters:
    comment: Altitude of Satellite (in KM)
    value: '500'
  states: {}
- name: ue_addr
  id: variable
  parameters:
    value: '"tcp://10.141.51.17:2001"'
  states: {}
- name: ul_band_fc
  id: variable
  parameters:
    value: '2560000000'
  states: {}
- name: analog_random_source_x_0
  id: analog_random_source_x
  parameters:
    max: '2'
    min: '0'
    num_samps: '1000'
    repeat: 'True'
    type: int
  states: {state: disabled}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    comment: Doppler Shift
    freq: doppler_freq
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_SIN_WAVE
  states: {}
- name: analog_sig_source_x_1
  id: analog_sig_source_x
  parameters:
    amp: '1'
    comment: Doppler Shift
    freq: doppler_freq
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_SIN_WAVE
  states: {}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    type: complex
  states: {state: disabled}
- name: blocks_delay_0
  id: blocks_delay
  parameters:
    delay: prop_delay
    type: complex
  states: {}
- name: blocks_delay_1
  id: blocks_delay
  parameters:
    delay: prop_delay
    type: complex
  states: {}
- name: blocks_multiply_xx_0
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: blocks_multiply_xx_1
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: blocks_throttle_1
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: qtgui_sink_x_0
  id: qtgui_sink_x
  parameters:
    bw: samp_rate
    fc: '2680000000'
    fftsize: '1024'
    type: complex
  states: {}
- name: zeromq_rep_sink_0
  id: zeromq_rep_sink
  parameters:
    address: tcp://0.0.0.0:2000
    timeout: '100'
    type: complex
  states: {}
- name: zeromq_rep_sink_1
  id: zeromq_rep_sink
  parameters:
    address: tcp://0.0.0.0:2001
    timeout: '100'
    type: complex
  states: {}
- name: zeromq_req_source_0
  id: zeromq_req_source
  parameters:
    address: nodeb_addr
    timeout: '100'
    type: complex
  states: {}
- name: zeromq_req_source_1
  id: zeromq_req_source
  parameters:
    address: ue_addr
    timeout: '100'
    type: complex
  states: {}

connections:
- [analog_sig_source_x_0, '0', blocks_multiply_xx_0, '0']
- [analog_sig_source_x_1, '0', blocks_multiply_xx_1, '1']
- [blocks_delay_0, '0', blocks_throttle_1, '0']
- [blocks_delay_1, '0', blocks_throttle_0, '0']
- [blocks_multiply_xx_0, '0', blocks_delay_1, '0']
- [blocks_multiply_xx_1, '0', blocks_delay_0, '0']
- [blocks_multiply_xx_1, '0', qtgui_sink_x_0, '0']
- [blocks_throttle_0, '0', zeromq_rep_sink_0, '0']
- [blocks_throttle_1, '0', zeromq_rep_sink_1, '0']
- [zeromq_req_source_0, '0', blocks_multiply_xx_0, '1']
- [zeromq_req_source_1, '0', blocks_multiply_xx_1, '0']

metadata:
  file_format: 1
