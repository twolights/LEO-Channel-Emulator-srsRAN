options:
  parameters:
    author: Yi-Kuang Evan Chen
    generate_options: qt_gui
    id: leo_channel
    output_language: python
    title: LEO Satellite Channel Emulator
  states: {}

blocks:
- name: delay_epsilon
  id: variable
  parameters:
    value: '1.00'
  states: {}
- name: distance_to_ue
  id: variable_qtgui_label
  parameters:
    formatter: 'lambda x: f''{x:,.3f}'''
    gui_hint: 1,2,1,1
    label: Distance to UE (KM)
    type: real
    value: '0'
  states: {}
- name: dl_band_fc
  id: variable
  parameters:
    value: '2680000000'
  states: {}
- name: dl_freq_label
  id: variable_qtgui_label
  parameters:
    formatter: 'lambda x: f''{x:,}'''
    gui_hint: 2,0,1,1
    label: DL Freq. (Hz)
    type: int
    value: dl_band_fc
  states: {}
- name: doppler_freq_dl
  id: variable_qtgui_label
  parameters:
    formatter: 'lambda x: f''{x:,.3f}'''
    gui_hint: 2,1,1,1
    label: DL Doppler Freq. (Hz)
    type: int
    value: '0'
  states: {}
- name: doppler_freq_ul
  id: variable_qtgui_label
  parameters:
    formatter: 'lambda x: f''{x:,.3f}'''
    gui_hint: 3,1,1,1
    label: UL Doppler Freq (Hz)
    type: int
    value: '0'
  states: {}
- name: elevation_angle
  id: variable_qtgui_label
  parameters:
    gui_hint: 0,1,1,2
    label: Satellite Elevation Angle (deg.)
    type: real
    value: '0'
  states: {}
- name: nodeb_addr
  id: variable
  parameters:
    value: '"tcp://10.141.51.18:2000"'
  states: {}
- name: nodeb_addr_label
  id: variable_qtgui_label
  parameters:
    gui_hint: 0,0,1,1
    label: gNodeB IP
    type: string
    value: nodeb_addr
  states: {}
- name: noise_voltage
  id: variable
  parameters:
    value: '0.005'
  states: {}
- name: normalized_doppler_freq_dl
  id: variable
  parameters:
    value: float(doppler_freq_dl / samp_rate)
  states: {}
- name: normalized_doppler_freq_ul
  id: variable
  parameters:
    value: float(doppler_freq_ul / samp_rate)
  states: {}
- name: orbiting_speed
  id: variable_qtgui_label
  parameters:
    gui_hint: 3,3,1,1
    label: Orbiting Speed (KM/s)
    type: real
    value: '0'
  states: {}
- name: prop_delay
  id: variable_qtgui_label
  parameters:
    gui_hint: 3,2,1,1
    label: Prop. Delay (samples)
    type: int
    value: '0'
  states: {}
- name: prop_delay_us
  id: variable_qtgui_label
  parameters:
    formatter: 'lambda x: f''{x:,.3f}'''
    gui_hint: 2,2,1,1
    label: Prop. Delay (us)
    type: real
    value: '0'
  states: {}
- name: relative_speed_label
  id: variable_qtgui_label
  parameters:
    formatter: 'lambda x: f''{x:,.3f}'''
    gui_hint: 1,1,1,1
    label: Relative Speed (KM/s)
    type: int
    value: '0'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '23040000'
  states: {}
- name: sat_altitude
  id: variable
  parameters:
    comment: Altitude of Satellite (in KM)
    value: '600'
  states: {}
- name: sat_altitude_label
  id: variable_qtgui_label
  parameters:
    gui_hint: 2,3,1,1
    label: Satellite Altitude (KM)
    type: int
    value: sat_altitude
  states: {}
- name: satellite_location
  id: variable_qtgui_label
  parameters:
    gui_hint: 1,3,1,1
    label: Satellite Location (deg.)
    type: real
    value: '0'
  states: {}
- name: ue_addr
  id: variable
  parameters:
    value: '"tcp://10.141.51.17:2001"'
  states: {}
- name: ue_addr_label
  id: variable_qtgui_label
  parameters:
    gui_hint: 1,0,1,1
    label: UE IP
    type: string
    value: ue_addr
  states: {}
- name: ue_location
  id: variable_qtgui_label
  parameters:
    gui_hint: 0,3,1,1
    label: UE Location (deg.)
    type: real
    value: '0'
  states: {}
- name: ul_band_fc
  id: variable
  parameters:
    value: '2560000000'
  states: {}
- name: ul_freq_label
  id: variable_qtgui_label
  parameters:
    formatter: 'lambda x: f''{x:,}'''
    gui_hint: 3,0,1,1
    label: UL Freq. (Hz)
    type: int
    value: ul_band_fc
  states: {}
- name: analog_sig_source_dl
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: dl_band_fc
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {state: disabled}
- name: analog_sig_source_ul
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: ul_band_fc
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {state: disabled}
- name: blocks_delay
  id: blocks_delay
  parameters:
    delay: prop_delay
    num_ports: '2'
    type: complex
  states: {}
- name: channel_model_dl
  id: channels_channel_model
  parameters:
    alias: channel_model_dl
    epsilon: delay_epsilon
    freq_offset: normalized_doppler_freq_dl
    noise_voltage: noise_voltage
    seed: '0'
    taps: '1.0'
  states: {}
- name: channel_model_ul
  id: channels_channel_model
  parameters:
    alias: channel_model_ul
    epsilon: delay_epsilon
    freq_offset: normalized_doppler_freq_ul
    noise_voltage: noise_voltage
    seed: '0'
    taps: '1.0'
  states: {}
- name: los_fading_model_dl
  id: channels_selective_fading_model
  parameters:
    K: '10.5293'
    LOS: 'True'
    N: '8'
    comment: |-
      NTN-TDL-C Specifies:
      Ricean K-factor = 10.224dB = 10.5293
    delays: (0.0, )
    fDTs: '0'
    mags: (0.9133, )
    ntaps: '8'
    seed: '0'
  states: {}
- name: los_fading_model_ul
  id: channels_selective_fading_model
  parameters:
    K: '10.5293'
    LOS: 'True'
    N: '8'
    comment: |-
      NTN-TDL-C Specifies:
      Ricean K-factor = 10.224dB = 10.5293
    delays: (0.0, )
    fDTs: '0'
    mags: (0.9133, )
    ntaps: '8'
    seed: '0'
  states: {}
- name: main_tabs
  id: qtgui_tab_widget
  parameters:
    label0: Downlink
    label1: Uplink
    num_tabs: '2'
  states: {}
- name: nlos_fading_model_dl
  id: channels_selective_fading_model
  parameters:
    LOS: 'False'
    N: '8'
    delays: (0.0, 71.35 * 1e-9 * samp_rate)
    fDTs: '0'
    mags: (0.087, 0.005)
    ntaps: '8'
    seed: '0'
  states: {}
- name: nlos_fading_model_ul
  id: channels_selective_fading_model
  parameters:
    LOS: 'False'
    N: '8'
    delays: (0.0, 71.35 * 1e-9 * samp_rate)
    fDTs: '0'
    mags: (0.087, 0.005)
    ntaps: '8'
    seed: '0'
  states: {}
- name: ntn_tdl_c_add_dl
  id: blocks_add_xx
  parameters:
    type: complex
  states: {}
- name: ntn_tdl_c_add_ul
  id: blocks_add_xx
  parameters:
    type: complex
  states: {}
- name: qtgui_sink_x_dl
  id: qtgui_sink_x
  parameters:
    bw: samp_rate
    fc: dl_band_fc
    fftsize: '1024'
    gui_hint: main_tabs@0
    name: Downlink
    showrf: 'True'
    type: complex
    wintype: window.WIN_HAMMING
  states: {}
- name: qtgui_sink_x_ul
  id: qtgui_sink_x
  parameters:
    bw: samp_rate
    fc: ul_band_fc
    fftsize: '1024'
    gui_hint: main_tabs@1
    name: Uplink
    showrf: 'True'
    type: complex
  states: {}
- name: throttle_dl
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: throttle_ul
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: zeromq_rep_sink_dl
  id: zeromq_rep_sink
  parameters:
    address: tcp://0.0.0.0:2000
    timeout: '100'
    type: complex
  states: {}
- name: zeromq_rep_sink_ul
  id: zeromq_rep_sink
  parameters:
    address: tcp://0.0.0.0:2001
    timeout: '100'
    type: complex
  states: {}
- name: zeromq_req_source_dl
  id: zeromq_req_source
  parameters:
    address: nodeb_addr
    timeout: '100'
    type: complex
  states: {}
- name: zeromq_req_source_ul
  id: zeromq_req_source
  parameters:
    address: ue_addr
    timeout: '100'
    type: complex
  states: {}

connections:
- [analog_sig_source_dl, '0', throttle_dl, '0']
- [analog_sig_source_ul, '0', throttle_ul, '0']
- [blocks_delay, '0', qtgui_sink_x_dl, '0']
- [blocks_delay, '0', zeromq_rep_sink_dl, '0']
- [blocks_delay, '1', qtgui_sink_x_ul, '0']
- [blocks_delay, '1', zeromq_rep_sink_ul, '0']
- [channel_model_dl, '0', blocks_delay, '0']
- [channel_model_ul, '0', blocks_delay, '1']
- [los_fading_model_dl, '0', ntn_tdl_c_add_dl, '0']
- [los_fading_model_ul, '0', ntn_tdl_c_add_ul, '0']
- [nlos_fading_model_dl, '0', ntn_tdl_c_add_dl, '1']
- [nlos_fading_model_ul, '0', ntn_tdl_c_add_ul, '1']
- [ntn_tdl_c_add_dl, '0', channel_model_dl, '0']
- [ntn_tdl_c_add_ul, '0', channel_model_ul, '0']
- [throttle_dl, '0', los_fading_model_dl, '0']
- [throttle_dl, '0', nlos_fading_model_dl, '0']
- [throttle_ul, '0', los_fading_model_ul, '0']
- [throttle_ul, '0', nlos_fading_model_ul, '0']
- [zeromq_req_source_dl, '0', throttle_dl, '0']
- [zeromq_req_source_ul, '0', throttle_ul, '0']

metadata:
  file_format: 1
