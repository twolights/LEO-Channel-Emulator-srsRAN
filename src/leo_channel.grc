options:
  parameters:
    author: Yi-Kuang Evan Chen
    generate_options: qt_gui
    id: leo_channel
    output_language: python
    title: LEO Satellite Channel Emulator
  states: {}

blocks:
- name: distance_to_ue
  id: variable_qtgui_label
  parameters:
    formatter: 'lambda x: f''{x:,.3f}'''
    gui_hint: 1,2,1,1
    label: Satellite Distance to UE (KM)
    type: real
    value: '0'
  states: {}
- name: dl_band_fc
  id: variable
  parameters:
    value: '2680000000'
  states: {}
- name: dl_freq_label
  id: variable_qtgui_label
  parameters:
    formatter: 'lambda x: f''{x:,}'''
    gui_hint: 2,0,1,1
    label: DL Freq. (Hz)
    type: int
    value: dl_band_fc
  states: {}
- name: doppler_freq_dl
  id: variable_qtgui_label
  parameters:
    formatter: 'lambda x: f''{x:,.3f}'''
    gui_hint: 2,1,1,1
    label: DL Doppler Freq. (Hz)
    type: int
    value: '0'
  states: {}
- name: doppler_freq_ul
  id: variable_qtgui_label
  parameters:
    formatter: 'lambda x: f''{x:,.3f}'''
    gui_hint: 3,1,1,1
    label: UL Doppler Freq (Hz)
    type: int
    value: '0'
  states: {}
- name: elevation_angle
  id: variable_qtgui_label
  parameters:
    gui_hint: 0,1,1,2
    label: Satellite Elevation Angle (deg.)
    type: real
    value: '0'
  states: {}
- name: nodeb_addr
  id: variable
  parameters:
    value: '"tcp://10.141.51.18:2000"'
  states: {}
- name: nodeb_addr_label
  id: variable_qtgui_label
  parameters:
    gui_hint: 0,0,1,1
    label: gNodeB IP
    type: string
    value: nodeb_addr
  states: {}
- name: orbiting_speed
  id: variable_qtgui_label
  parameters:
    gui_hint: 3,3,1,1
    label: Orbiting Speed (KM/s)
    type: real
    value: '0'
  states: {}
- name: prop_delay
  id: variable_qtgui_label
  parameters:
    gui_hint: 3,2,1,1
    label: Prop. Delay (samples)
    type: int
    value: '0'
  states: {}
- name: prop_delay_us
  id: variable_qtgui_label
  parameters:
    formatter: 'lambda x: f''{x:,.3f}'''
    gui_hint: 2,2,1,1
    label: Prop. Delay (us)
    type: real
    value: '0'
  states: {}
- name: relative_speed_label
  id: variable_qtgui_label
  parameters:
    formatter: 'lambda x: f''{x:,.3f}'''
    gui_hint: 1,1,1,1
    label: Relative Speed (KM/s)
    type: int
    value: '0'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '23040000'
  states: {}
- name: sat_altitude
  id: variable
  parameters:
    comment: Altitude of Satellite (in KM)
    value: '600'
  states: {}
- name: sat_altitude_label
  id: variable_qtgui_label
  parameters:
    gui_hint: 2,3,1,1
    label: Satellite Altitude (KM)
    type: int
    value: sat_altitude
  states: {}
- name: satellite_location
  id: variable_qtgui_label
  parameters:
    gui_hint: 1,3,1,1
    label: Satellite Location (deg.)
    type: real
    value: '0'
  states: {}
- name: ue_addr
  id: variable
  parameters:
    value: '"tcp://10.141.51.17:2001"'
  states: {}
- name: ue_addr_label
  id: variable_qtgui_label
  parameters:
    gui_hint: 1,0,1,1
    label: UE IP
    type: string
    value: ue_addr
  states: {}
- name: ue_location
  id: variable_qtgui_label
  parameters:
    gui_hint: 0,3,1,1
    label: UE Location (deg.)
    type: real
    value: '0'
  states: {}
- name: ul_band_fc
  id: variable
  parameters:
    value: '2560000000'
  states: {}
- name: ul_freq_label
  id: variable_qtgui_label
  parameters:
    formatter: 'lambda x: f''{x:,}'''
    gui_hint: 3,0,1,1
    label: UL Freq. (Hz)
    type: int
    value: ul_band_fc
  states: {}
- name: blocks_delay_0
  id: blocks_delay
  parameters:
    delay: prop_delay
    type: complex
  states: {}
- name: blocks_delay_1
  id: blocks_delay
  parameters:
    delay: prop_delay
    type: complex
  states: {}
- name: blocks_freqshift_cc_0
  id: blocks_freqshift_cc
  parameters:
    freq: doppler_freq_dl
    sample_rate: samp_rate
  states: {}
- name: blocks_freqshift_cc_1
  id: blocks_freqshift_cc
  parameters:
    freq: doppler_freq_ul
    sample_rate: samp_rate
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: blocks_throttle_1
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: qtgui_sink_x_0
  id: qtgui_sink_x
  parameters:
    bw: samp_rate
    fc: '2680000000'
    fftsize: '1024'
    type: complex
  states: {}
- name: qtgui_sink_x_1
  id: qtgui_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: complex
  states: {}
- name: zeromq_rep_sink_0
  id: zeromq_rep_sink
  parameters:
    address: tcp://0.0.0.0:2000
    timeout: '100'
    type: complex
  states: {}
- name: zeromq_rep_sink_1
  id: zeromq_rep_sink
  parameters:
    address: tcp://0.0.0.0:2001
    timeout: '100'
    type: complex
  states: {}
- name: zeromq_req_source_0
  id: zeromq_req_source
  parameters:
    address: nodeb_addr
    timeout: '100'
    type: complex
  states: {}
- name: zeromq_req_source_1
  id: zeromq_req_source
  parameters:
    address: ue_addr
    timeout: '100'
    type: complex
  states: {}

connections:
- [blocks_delay_0, '0', blocks_throttle_1, '0']
- [blocks_delay_1, '0', blocks_throttle_0, '0']
- [blocks_freqshift_cc_0, '0', blocks_delay_1, '0']
- [blocks_freqshift_cc_1, '0', blocks_delay_0, '0']
- [blocks_throttle_0, '0', qtgui_sink_x_1, '0']
- [blocks_throttle_0, '0', zeromq_rep_sink_0, '0']
- [blocks_throttle_1, '0', qtgui_sink_x_0, '0']
- [blocks_throttle_1, '0', zeromq_rep_sink_1, '0']
- [zeromq_req_source_0, '0', blocks_freqshift_cc_0, '0']
- [zeromq_req_source_1, '0', blocks_freqshift_cc_1, '0']

metadata:
  file_format: 1
  grc_version: 3.10.9.2
